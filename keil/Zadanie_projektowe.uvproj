# Keil uVision project Zadanie_projektowe.uvproj, settings and files
target U1_Master (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: U1_Master +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: U1_Master.c U3_7SEG.c U5_Motor.c U8_LCD.c
target U3_7SEG (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: U3_7SEG +hex
  c flags: Optimize=8 SizeSpeed=1
target U5_Motor (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: U5_Motor +hex
  c flags: Optimize=8 SizeSpeed=1
target U8_LCD (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: U8_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
